FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-fix-full-socket-connection-flush.patch \
           "
