#This recipe can fail because it doesn't manage correclty building outside source tree
inherit autotools-brokensep
