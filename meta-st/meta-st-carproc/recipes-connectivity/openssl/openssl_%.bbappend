FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"

SRC_URI += "file://Expose-engines-with-128-and-256-bits-AES-GCM-support.patch"
