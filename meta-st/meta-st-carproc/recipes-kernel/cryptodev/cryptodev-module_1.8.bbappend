FILESEXTRAPATHS_append := "${THISDIR}/cryptodev"

SRC_URI += "file://0001-Adjust-to-another-change-in-the-user-page-API.patch"
