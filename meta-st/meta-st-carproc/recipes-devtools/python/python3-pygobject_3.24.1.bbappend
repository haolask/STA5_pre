#We don't want cairo since it is GPLv3, and we don't need it.
PACKAGECONFIG_remove = "cairo"
