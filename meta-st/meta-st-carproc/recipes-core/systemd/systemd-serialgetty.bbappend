FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://serial-getty@.service"
