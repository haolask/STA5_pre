INSANE_SKIP_${PN}-examples-dev += "libdir dev-elf"